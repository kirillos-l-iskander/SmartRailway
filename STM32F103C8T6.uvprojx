# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c SchedulerConfig.c SchedulerConfig.h Scheduler.c Scheduler.h Config.h Rcc.c Rcc.h Gpio.c Gpio.h Afio.c Afio.h Timer.c Timer.h Adc.c Adc.h Spi.c Spi.h Led.c Led.h Nrf.c Nrf.h Irsnsr.c Irsnsr.h Lcd.c Lcd.h Rtryencdr.c Rtryencdr.h Pid.c Pid.h Motor.c Motor.h Station.c Station.h Train.c Train.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0
